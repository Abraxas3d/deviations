options:
  parameters:
    author: Abraxas3d
    description: for GRCon20 Deviations
    generate_options: qt_gui
    id: send_jpg
    output_language: python
    title: Shinto CDMA Signals
  states: {}

blocks:
- name: cdma_bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707 + 0.707j,  -0.707 - 0.707j]'
    imag_sect: '1'
    real_sect: '1'
    rot_sym: '2'
    sym_map: '[0,1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: cdma_qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707 + 0.707j, -0.707 + 0.707j,  -0.707 - 0.707j, 0.707 -0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: chips_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: header_length
  id: variable
  parameters:
    value: '4'
  states: {}
- name: my_preamble_1
  id: variable
  parameters:
    value: '[(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j)]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_length
  id: variable
  parameters:
    value: '96'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/chips_per_symbol
  states: {}
- name: blocks_complex_to_float_0_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/data_check_1.txt
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_after_map.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/Shinto_CDMA_send_combined.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    comment: |-
      we will need a synchronization
      DEADBEEF is (222, 173, 190, 239)
      5A0FBE66 is (90, 15, 190, 102)
    offset: '0'
    period: packet_length + header_length
    type: byte
    vector: (90, 15, 190, 102)
  states: {state: disabled}
- name: blocks_vector_insert_x_0_0
  id: blocks_vector_insert_x
  parameters:
    comment: |-
      we will need a synchronization
      DEADBEEF is (222, 173, 190, 239)
      5A0FBE66 is (90, 15, 190, 102)
    offset: '0'
    period: (header_length + packet_length)*chips_per_symbol
    type: byte
    vector: (34, 221, 34, 221, 221, 34, 221, 34, 34, 34, 34, 34, 221, 221, 221, 221, 221, 34, 221, 221, 221, 221, 221, 34, 34, 221, 221, 34, 34, 221, 221, 34)
  states: {}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/abraxas3d/Documents/Deviations/Deviations_1_1.wav
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: cdma_qpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      0 maps to 01010101
      1 maps to 10101010
    map: '[34, 221]'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: QPSK After Modulator
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: QPSK After Modulator
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Right After Vector Insert
    size: 1024*2
    srate: samp_rate
    type: float
    ymax: '255'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: QPSK After Modulator
    size: 1024*4*4*2
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data_stream_1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: chip_stream_1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data_stream_1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: chip_stream_1
  states: {}

connections:
- [blocks_complex_to_float_0_0_1, '0', blocks_wavfile_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0_1, '1', blocks_wavfile_sink_0_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_map_bb_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', virtual_sink_1, '0']
- [blocks_vector_insert_x_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_insert_x_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_complex_to_float_0_0_1, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_map_bb_0, '0', blocks_vector_insert_x_0_0, '0']
- [virtual_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [virtual_source_0_1, '0', digital_constellation_modulator_0_0, '0']

metadata:
  file_format: 1
