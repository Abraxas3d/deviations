options:
  parameters:
    author: Abraxas3d
    description: for GRCon20 Deviations
    generate_options: qt_gui
    id: send_jpg
    output_language: python
    title: Shinto CDMA Signals
  states: {}

blocks:
- name: cdma_bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707 + 0.707j,  -0.707 - 0.707j]'
    imag_sect: '1'
    real_sect: '1'
    rot_sym: '2'
    sym_map: '[0,1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: cdma_qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707 + 0.707j, -0.707 + 0.707j,  -0.707 - 0.707j, 0.707 -0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: chips_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: header_length
  id: variable
  parameters:
    value: '4'
  states: {}
- name: my_preamble
  id: variable
  parameters:
    value: '[(0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j)]'
  states: {}
- name: my_preamble_1
  id: variable
  parameters:
    value: '[(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j),(-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 - 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j), (-0.707 + 0.707j)]'
  states: {}
- name: my_preamble_2
  id: variable
  parameters:
    value: '[(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j),(-0.707 - 0.707j),(-0.707 - 0.707j),(-0.707 + 0.707j)]'
  states: {}
- name: my_preamble_3
  id: variable
  parameters:
    value: '[( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 + 0.707j),( 0.707 - 0.707j),( 0.707 - 0.707j),]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_length
  id: variable
  parameters:
    value: '96'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/chips_per_symbol
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    comment: check succeeded with skip 5
    file: /home/abraxas3d/Documents/Deviations/test_after_demod.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/despread_1.jpg
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_after_map.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_2_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_before_map.txt
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: (packet_length*8*8)//2
    n: (header_length*8*8)//2 + (packet_length*8*8)//2
    offset: '0'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_2
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {}
- name: blocks_skiphead_3
  id: blocks_skiphead
  parameters:
    comment: (header_length*8*chips_per_symbol)//2
    num_items: '128'
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: corr_start
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_2
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    comment: |-
      get the demodulated 
      symbols into bytes
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_3
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/Deviations_1_1.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: cdma_qpsk
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: sps
    symbols: my_preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_map_bb_2
  id: digital_map_bb
  parameters:
    map: '[1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: (2*pi)/100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Looking For Correlation Estimation
    size: '4000'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: from_correlator
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: demodulated_chips
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: from_correlator
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: demodulated_chips
  states: {}

connections:
- [blocks_float_to_complex_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_packed_to_unpacked_xx_2, '0', blocks_file_sink_0_2_0, '0']
- [blocks_packed_to_unpacked_xx_2, '0', digital_map_bb_2, '0']
- [blocks_skiphead_0, '0', blocks_unpacked_to_packed_xx_3, '0']
- [blocks_skiphead_3, '0', blocks_keep_m_in_n_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_skiphead_3, '0']
- [blocks_unpacked_to_packed_xx_2, '0', blocks_file_sink_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_2, '0', virtual_sink_3, '0']
- [blocks_unpacked_to_packed_xx_3, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_2, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_corr_est_cc_0, '0', virtual_sink_0, '0']
- [digital_map_bb_2, '0', blocks_skiphead_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_corr_est_cc_0, '0']
- [virtual_source_0, '0', blocks_tagged_stream_align_0, '0']
- [virtual_source_2, '0', blocks_packed_to_unpacked_xx_2, '0']

metadata:
  file_format: 1
