options:
  parameters:
    author: Abraxas3d
    description: for GRCon20 Deviations
    generate_options: qt_gui
    id: send_jpg
    output_language: python
    title: Shinto CDMA Signals
  states: {}

blocks:
- name: cdma_bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707 + 0.707j,  -0.707 - 0.707j]'
    imag_sect: '1'
    real_sect: '1'
    rot_sym: '2'
    sym_map: '[0,1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: cdma_qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707 + 0.707j, -0.707 + 0.707j,  -0.707 - 0.707j, 0.707 -0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: chips_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: header_length
  id: variable
  parameters:
    value: '4'
  states: {}
- name: my_preamble
  id: variable
  parameters:
    value: '[(0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 - 0.707j), (-0.707 + 0.707j), (0.707 - 0.707j), (-0.707 +0.707j), (0.707 + 0.707j), (-0.707 - 0.707j),  (0.707 + 0.707j), (-0.707 - 0.707j)]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_length
  id: variable
  parameters:
    value: '96'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: samp_rate/chips_per_symbol
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      8 times larger
      than data_check
      as expected
    file: /home/abraxas3d/Documents/Deviations/spread_check.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/data_check.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    comment: check succeeded with skip 5
    file: /home/abraxas3d/Documents/Deviations/test_after_demod.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_despread_received.jpg
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    comment: |-
      128 times larger
      than spread_check
      as expected
    file: /home/abraxas3d/Documents/Deviations/symbol_check.txt
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_after_map.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_2_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_before_map.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abraxas3d/Pictures/Object25338_Crack_in_the_Ground.jpg
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: (packet_length*8*8)//2
    n: (header_length*8*8)//2 + (packet_length*8*8)//2
    offset: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_2
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_skiphead_3
  id: blocks_skiphead
  parameters:
    num_items: ((header_length*8*chips_per_symbol)//2)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"unspread_len"'
    packet_len: (packet_length + header_length)*chips_per_symbol
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"spread_len"'
    packet_len: (packet_length+header_length)*chips_per_symbol
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: packet_length + header_length
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: corr_start
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: unspread_len
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: spread_len
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_2
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    comment: |-
      get the demodulated 
      symbols into bytes
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_3
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    comment: |-
      we will need a synchronization
      DEADBEEF is (222, 173, 190, 239)
      5A0FBE66 is (90, 15, 190, 102)
    offset: '0'
    period: packet_length + header_length
    type: byte
    vector: (90, 15, 190, 102)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: list(range(0,255))
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: cdma_qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: cdma_qpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: sps
    symbols: my_preamble
    threshold: '0.9'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      0 maps to 00100010
      1 maps to 11011101
    map: '[34, 221]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[0,255]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: (2*pi)/100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: QPSK After Modulator
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: QPSK After Modulator
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: QPSK After Modulator
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Looking For Correlation Estimation
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data_stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: chip_stream
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: modulated_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: demodulated_chips
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data_stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: data_stream
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: chip_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: modulated_stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: demodulated_chips
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_m_in_n_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_map_bb_0, '0']
- [blocks_packed_to_unpacked_xx_1, '0', digital_map_bb_1, '0']
- [blocks_packed_to_unpacked_xx_2, '0', blocks_file_sink_0_2, '0']
- [blocks_packed_to_unpacked_xx_2, '0', blocks_unpacked_to_packed_xx_3, '0']
- [blocks_skiphead_3, '0', blocks_keep_m_in_n_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', blocks_null_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', blocks_tag_debug_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', virtual_sink_1, '0']
- [blocks_stream_to_tagged_stream_0_0_1_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1_0, '0', blocks_tag_debug_0_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_skiphead_3, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, blocks_message_debug_0_0_0, print_pdu]
- [blocks_throttle_0, '0', blocks_vector_insert_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_stream_to_tagged_stream_0_0_1, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_2, '0', blocks_file_sink_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_2, '0', virtual_sink_3, '0']
- [blocks_unpacked_to_packed_xx_3, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_3, '0', blocks_null_sink_1, '0']
- [blocks_vector_insert_x_0, '0', blocks_stream_to_tagged_stream_0_0_1_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_2, '0']
- [digital_constellation_modulator_0_0, '0', blocks_file_sink_0_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_tag_debug_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_modulator_0_0, '0', virtual_sink_2, '0']
- [digital_corr_est_cc_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_map_bb_1, '0', blocks_unpacked_to_packed_xx_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_corr_est_cc_0, '0']
- [virtual_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [virtual_source_0_0, '0', blocks_packed_to_unpacked_xx_1, '0']
- [virtual_source_0_1, '0', blocks_file_sink_0_2_0, '0']
- [virtual_source_0_1, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_2, '0', blocks_packed_to_unpacked_xx_2, '0']

metadata:
  file_format: 1
