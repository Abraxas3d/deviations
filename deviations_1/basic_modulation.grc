options:
  parameters:
    author: Abraxas3d
    copyright: Public Domain
    description: BPSK modulator for the Personal Locator Beacon signal for Deviations Capture the Flag for GNU Radio Conference 2020.
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: BPSK PLB Uplink
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''11111111'''
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: my_bpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[1, -1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: my_formatter
  id: variable
  parameters:
    value: digital.header_format_counter(access_code, 1, 1)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: plb_frequency
  id: variable
  parameters:
    value: '406040000'
  states: {}
- name: qt_gui_sink_bandwidth
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (6000-(6000*excess_bw))*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '200'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 406.040 MHz
    freq: plb_frequency
    offset: '0'
    phase: '0'
    samp_rate: plb_frequency
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_random_source.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_random_received.txt
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_BPSK_modulation.txt
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/doppler.txt
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '5'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '40'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_vector_insert_x_1
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: '15'
    type: byte
    vector: '[0]'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1]'
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      6000/8 bits per byte is
      750 bytes per second
      each byte is 32 samples
      24kHz sample rate?
    constellation: my_bpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: my_bpsk
    fmax: '10'
    fmin: '-10'
    loop_bw: (2*pi)/100
    showports: 'true'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: (2*pi)/100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: my_formatter
    len_tag_key: '"packet_len"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0
    name: After Modulator
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1
    name: After Constellation Receiver
    size: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: plb_frequency
    fftsize: '1024'
    gui_hint: 2,0
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 2,1
    label1: Error
    label2: Phase
    label3: Frequency
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0
    name: modulated data
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1
    name: demodulated data
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_file_sink_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [analog_random_source_x_0, '0', blocks_vector_insert_x_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_null_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_insert_x_1, '0', blocks_null_sink_1, '0']
- [blocks_vector_insert_x_1, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_insert_x_1, '0']
- [digital_constellation_modulator_0, '0', blocks_file_sink_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '1']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_skiphead_0, '0']
- [digital_constellation_receiver_cb_0, '1', qtgui_time_sink_x_0, '0']
- [digital_constellation_receiver_cb_0, '2', qtgui_time_sink_x_0, '1']
- [digital_constellation_receiver_cb_0, '3', qtgui_time_sink_x_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_time_sink_x_2, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '1']

metadata:
  file_format: 1
