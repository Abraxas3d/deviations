options:
  parameters:
    author: Abraxas3d
    description: Chirp Transmitter for PLB
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Chirp Transmitter
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    value: (interpolation_rate/2) - samp_rate
  states: {}
- name: doppler
  id: variable_function_probe
  parameters:
    block_id: dd
    function_name: level
    poll_rate: '10000'
    value: '0'
  states: {}
- name: interpolation_factor
  id: variable
  parameters:
    value: '10'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: samp_rate*interpolation_factor
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: (13/19)/5
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: (3/19)/5
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: (7/19)/5
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: (19/19)/5
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '.7'
    freq: carrier+doppler
    offset: '0'
    phase: '0'
    samp_rate: interpolation_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '2000'
    freq: '0.05'
    offset: '0'
    phase: '0'
    samp_rate: interpolation_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: carrier + 6000 + doppler
    interp: '1'
    low_cutoff_freq: carrier - 5000 + doppler
    samp_rate: interpolation_rate
    type: interp_fir_filter_ccf
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: interpolation_factor
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/abraxas3d/Documents/Deviations/ChristmasValley.wav
    nchan: '2'
    samp_rate: interpolation_rate
  states: {}
- name: dd
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '1'
    image_file: /home/abraxas3d/Documents/Deviations/MayanCalendar20160513.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '1'
    width: '345'
  states: {}
- name: qtgui_sink_x_2_0_0
  id: qtgui_sink_x
  parameters:
    bw: interpolation_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: 0,0
    name: On the Air
    plotconst: 'False'
    rate: '100'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_1_0_0, '0', blocks_add_xx_0, '3']
- [analog_sig_source_x_1_0_0_0, '0', blocks_add_xx_0, '4']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_3, '0', dd, '0']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_repeat_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_1, '0', qtgui_sink_x_2_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_add_xx_0, '5']

metadata:
  file_format: 1
