options:
  parameters:
    generate_options: qt_gui
    id: g3ruh_test
    output_language: python
    title: G3RUH 9600 Baud Test
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '439050000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 2e6 is the minimum sample rate for HackRF One
    value: 2e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '80000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/kb5mu/Desktop/GRCon 2020 CTF/GRC Tests/9600baud-test.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/kb5mu/Desktop/GRCon 2020 CTF/GRC Tests/9600baud-test.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/kb5mu/Documents/git/gr-satellites/satellite-recordings/us01.wav
    repeat: 'True'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decim
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '30'
    dc_offset_mode0: '2'
    freq0: frequency-freq_offset
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decim
    fc: frequency
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: 1200+500
    baudrate: '1200'
    deviation: '500'
    iq: 'True'
    samp_rate: samp_rate/decim
  states: {state: disabled}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
    options: '"--costas_bw 150"'
  states: {}
- name: satellites_ax25_deframer_0_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'False'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9600'
    iq: 'True'
    samp_rate: samp_rate/decim
    subaudio: 'False'
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    file: /home/kb5mu/Desktop/GRCon 2020 CTF/GRC Tests/g3ruh_recv.kiss
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_afsk_demodulator_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_fsk_demodulator_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [satellites_afsk_demodulator_0, '0', satellites_ax25_deframer_0_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_ax25_deframer_0, out, satellites_kiss_file_sink_0, in]
- [satellites_ax25_deframer_0_0, out, blocks_message_debug_0, print_pdu]
- [satellites_ax25_deframer_0_0, out, satellites_kiss_file_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']

metadata:
  file_format: 1
