options:
  parameters:
    author: Abraxas3d
    description: Chirp Transmitter for PLB
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Chirp Transmitter
  states: {}

blocks:
- name: Fs
  id: variable
  parameters:
    value: '2.1'
  states: {}
- name: amplitude
  id: variable
  parameters:
    value: '1300'
  states: {}
- name: carrier
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: doppler
  id: variable
  parameters:
    value: '5974'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/test_madrid_tx.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
