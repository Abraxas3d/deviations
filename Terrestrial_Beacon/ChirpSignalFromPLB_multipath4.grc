options:
  parameters:
    author: Abraxas3d
    description: Chirp Transmitter for PLB
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Chirp Transmitter
  states: {}

blocks:
- name: Fs
  id: variable
  parameters:
    value: '2.1'
  states: {}
- name: amplitude
  id: variable
  parameters:
    value: '1300'
  states: {}
- name: carrier
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: voice_offset
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: voice_offset2
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1600'
    low_cutoff_freq: '300'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '100'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '.35'
    type: float
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/from_AZ_ham.wav
    repeat: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier
    comment: firdes.low_pass(1,samp_rate,samp_rate/(2*decim), 200)
    decim: decim
    samp_rate: '768000'
    taps: firdes.low_pass(1,samp_rate,3000, 200)
    type: fcf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier+voice_offset
    comment: firdes.low_pass(1,samp_rate,samp_rate/(2*decim), 200)
    decim: decim
    samp_rate: '768000'
    taps: firdes.low_pass(1,samp_rate,4000, 200)
    type: fcf
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier+voice_offset2
    comment: firdes.low_pass(1,samp_rate,samp_rate/(2*decim), 200)
    decim: decim
    samp_rate: '768000'
    taps: firdes.low_pass(1,samp_rate,4000, 200)
    type: fcf
  states: {}
- name: qtgui_sink_x_2_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0
    name: At the End
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_2_0_0
  id: qtgui_sink_x
  parameters:
    bw: '768000'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0
    name: Off the Air
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_2_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: After Xlating
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_agc_xx_0, '0', qtgui_sink_x_2_0_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_0, '0']
- [blocks_complex_to_mag_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_2_0, '0']
- [blocks_wavfile_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_wavfile_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_sink_x_2_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
