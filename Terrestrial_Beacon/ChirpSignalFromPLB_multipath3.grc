options:
  parameters:
    author: Abraxas3d
    description: Chirp Transmitter for PLB
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Chirp Transmitter
  states: {}

blocks:
- name: Fs
  id: variable
  parameters:
    value: '2.1'
  states: {}
- name: amplitude
  id: variable
  parameters:
    value: '1300'
  states: {}
- name: carrier
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: voice_offset
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: voice_offset2
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.500'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '-amplitude'
    comment: 300 to 1600 hz
    freq: Fs
    offset: amplitude + 300
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '-200'
    freq: Fs/30
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: carrier
    offset: '0'
    phase: '0'
    samp_rate: 16*48000
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: carrier+voice_offset
    offset: '0'
    phase: '0'
    samp_rate: 16*48000
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: carrier+voice_offset2
    offset: '0'
    phase: '0'
    samp_rate: 16*48000
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '105000'
    low_cutoff_freq: '95000'
    samp_rate: '768000'
    type: fir_filter_fff
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: carrier+voice_offset+5000
    low_cutoff_freq: carrier+voice_offset-5000
    samp_rate: '768000'
    type: fir_filter_fff
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: carrier+voice_offset2+5000
    low_cutoff_freq: carrier+voice_offset2-5000
    samp_rate: '768000'
    type: fir_filter_fff
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '.1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '16'
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '16'
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: '16'
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.9'
    samp_rate: samp_rate
    sensitivity: (2*pi)
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/abraxas3d/Documents/Deviations/from_AZ_ham.wav
    samp_rate: '768000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/file1.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abraxas3d/Documents/Deviations/file2.wav
    repeat: 'False'
  states: {}
- name: qtgui_sink_x_2_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*decim
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0
    name: On the Air
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_2_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [band_pass_filter_0_0, '0', blocks_add_xx_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_0_0, '1']
- [band_pass_filter_0_0_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_vco_f_0, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_1, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_2_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_repeat_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_vco_f_0, '0', blocks_repeat_0, '0']
- [blocks_wavfile_source_0, '0', blocks_repeat_0_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_repeat_0_0_0, '0']

metadata:
  file_format: 1
