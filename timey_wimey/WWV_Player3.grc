options:
  parameters:
    generate_options: qt_gui
    id: WWV_player
    output_language: python
    title: WWV Player
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: xlat_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '10000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '4'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '120'
    low_cutoff_freq: '80'
    samp_rate: samp_rate/4
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/kb5mu/Desktop/WWV-bits.bin
    type: int
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '48'
    type: int
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.2'
    init: '0'
    low: '.1'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/kb5mu/Desktop/WWVsubtone.wav
    samp_rate: int(samp_rate/4)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/kb5mu/Desktop/mangled32.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-50000'
    decim: '1'
    samp_rate: samp_rate
    taps: xlat_taps
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"100 Hz Subband"'
    size: '32000'
    srate: samp_rate/4
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"RMS"'
    size: '32000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Threshold"'
    size: '32000'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: subband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: subband
  states: {}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_int_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_int_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [virtual_source_0, '0', audio_sink_0_0, '0']
- [virtual_source_0, '0', blocks_rms_xx_0, '0']
- [virtual_source_0, '0', blocks_wavfile_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
