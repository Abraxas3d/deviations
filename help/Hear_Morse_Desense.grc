options:
  parameters:
    author: Paul Williamson KB5MU
    generate_options: qt_gui
    id: Hear_Morse_Desense
    output_language: python
    title: Hear Morse Code from Noise Desense
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Lie about the sample rate to make it play slower
    value: '24000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.8'
    freq: '600'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Suppress the
      lower level noise
      completely
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Turn it into
      nice clean
      modulated
      audio!
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.01'
    comment: |-
      Sketchy envelope
      detector
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Tweak these to
      match the amplitude
      in the WAV file
    high: '.5'
    init: '0'
    low: '.2'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    comment: Make it digital
    high: '.05'
    init: '0'
    low: '.005'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/kb5mu/Downloads/help.wav
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*32
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: morse_key_waveform
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: morse_key_waveform
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_xx_1, '0', audio_sink_1, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_threshold_ff_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_1, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
